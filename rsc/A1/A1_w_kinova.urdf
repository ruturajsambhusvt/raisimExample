Commit message: Verified Kinova arm dynamics

File: rsc/A1/A1_w_kinova.urdf (robot description, URDF)
Before this commit: robot A1, 30 links, 29 joints
Joints:
- joint connect_root_and_world: origin xyz=-0.1 0.0 0.01 rpy=0 0 0 -> xyz=-0.1 0.0 0.1 rpy=0 0 0
